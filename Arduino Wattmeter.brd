# Repository thaaraak/QST-Watt-Meter-

## EAGLE design Arduino Wattmeter.brd

Parts:
C1, C2, C3, C5, C6, C9, C10, C11, C12, C13: 100nF; 1206
C4: 470uF; C5B3.5
C7: 470pF; 1206
C8: 1uF; 1206
C14, C15: 22pF; 1206
J1, J2, J3, J5: CONN_04; 1X04
J4: CONN_03X2NO_SILK; 2X3-NS
L1, L2: 47uH; BS75
Q1: CRYTALHC49S; HC49/S
U1: 328P; DIP28
U2: AP2202-ADJ; SOT23-5
U3, U4: LF398; DIP08

Connections:
5V: C13.2, J1.4, J3.2, J5.4, L1.2, L2.2, U2.1 (VIN)
-VCC: C9.1, C10.1, J1.2, U3.4 (V-), U4.4 (V-)
ENCA: J2.1, U1.4 (PD2(INT0))
ENCB: J2.2, U1.5 (PD3(INT1))
FWD: J5.2, U3.3 (INPUT)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.1, J1.3, J2.3, J3.1, J4.6, J5.3, U1.8 (GND), U1.22 (GND), U2.2 (GND), U3.7 (REF), U4.7 (REF)
unnamed: C2.2, U1.21 (AREF)
unnamed: C15.2, Q1.2, U1.9 (PB6(XTAL1/TOSC1))
unnamed: C14.2, Q1.1, U1.10 (PB7(XTAL2/TOSC2))
unnamed: C4.1, C5.1, J4.2, L2.1, U1.7 (VCC)
unnamed: U1.25 (PC2(ADC2)), U3.8 (LOGIC), U4.8 (LOGIC)
unnamed: J3.4, U1.27 (PC4(ADC4/SDA))
unnamed: C7.1, U2.4 (BYP)
unnamed: J3.3, U1.28 (PC5(ADC5/SCL))
unnamed: C8.1, U1.23 (PC0(ADC0)), U2.5 (VOUT)
unnamed: C6.1, U4.6 (CH)
unnamed: U1.24 (PC1(ADC1)), U3.5 (OUT)
unnamed: C1.1, U3.6 (CH)
unnamed: U1.26 (PC3(ADC3)), U4.5 (OUT)
unnamed: C3.2, L1.1, U1.20 (AVCC)
unnamed: J4.4, U1.17 (PB3(MOSI/OC2))
unnamed: J4.1, U1.18 (PB4(MISO))
unnamed: J4.3, U1.19 (PB5(SCK))
unnamed: J4.5, U1.1 (PC6(/RESET))
REFL: J5.1, U4.3 (INPUT)
SWITCH: J2.4, U1.14 (PB0(ICP))
VCC: C11.1, C12.1, J1.1, U3.1 (V+), U4.1 (V+)

Board: 2 copper layers, 100.0 x 80.0 mm, 27 parts (15 on the bottom side), 27 nets.

## EAGLE design RFInput.brd

Parts:
C1, C2, C4, C5, C6, C8: 0.001uF; 1206
C3, C7: 0.1uF; 1206
J1, J2: BNCPTH; BNC
J3: CONN_04; 1X04
L1, L2: 100uH; BS75
R1, R2: 52.3; 0805
U$1, U$2: AD8307; SO08

Connections:
5V: J3.4, L1.2, L2.2
GND: C2.1, C3.1, C4.1, C6.1, C7.1, C8.1, J1.GND, J2.GND, J3.3, R1.1, R2.1, U$1.2 (COM), U$2.2 (COM)
unnamed: C1.2, U$1.8 (IN+)
unnamed: C2.2, U$1.1 (IN-)
unnamed: C3.2, L1.1, U$1.6 (ENB), U$1.7 (VPS)
unnamed: C5.1, J2.S (OUT), R2.2
unnamed: C5.2, U$2.8 (IN+)
unnamed: C6.2, U$2.1 (IN-)
unnamed: C7.2, L2.1, U$2.6 (ENB), U$2.7 (VPS)
unnamed: C1.1, J1.S (OUT), R1.2
OUT1: C4.2, J3.2, U$1.4 (OUT)
OUT2: C8.2, J3.1, U$2.4 (OUT)

Board: 2 copper layers, 100.0 x 80.0 mm, 17 parts (0 on the bottom side), 12 nets.

## EAGLE design RFInput VERSION 2.brd

Board: 2 copper layers, 100.0 x 80.0 mm, 20 parts (0 on the bottom side), 13 nets.

Parts:
5V, 5V1: 2,54/1,1
C1, C2, C4, C5: 0.001uF; 1206
C3, C6: 0.1uF; 1206
GND, GND1: 2,54/1,1
J1, J2: BNCPTH; BNC
L1, L2: 100uH; BS75
OUT, OUT1: 2,54/1,1
R1, R2: 52.3; 0805
U$1, U$2: AD8307; SO08

Connections:
GND: C2.1, C3.1, C5.1, C6.1, GND.1, GND1.1, J1.GND, J2.GND, R1.1, R2.1, U$1.2, U$2.2
unnamed: C1.2, U$1.8
unnamed: C2.2, U$1.1
unnamed: C3.2, L1.1, U$1.6, U$1.7
unnamed: 5V.1, L1.2
unnamed: OUT.1, U$1.4
unnamed: C4.1, J2.S, R2.2
unnamed: C4.2, U$2.8
unnamed: C5.2, U$2.1
unnamed: C6.2, L2.1, U$2.6, U$2.7
unnamed: 5V1.1, L2.2
unnamed: OUT1.1, U$2.4
unnamed: C1.1, J1.S, R1.2

## Commit log

2020-02-05 New files
2020-02-16 fixed with via

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
